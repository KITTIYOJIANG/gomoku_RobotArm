# Keil uVision project Jibot1-32.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Jibot1-32 +hex
  c flags: Optim=4 v6Lang=1 v6LangP=5
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,SAFE_STAGE1
  c include: ..\USER;..\Libraries\src;..\Libraries\inc;..\Startup;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../USER/: stm32f10x_it.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_wwdg.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group src
    ../src/: z_delay.c z_global.c z_gpio.c z_ps2.c z_rcc.c z_timer.c z_usart.c z_w25q64.c z_adc.c z_kinematics.c z_action.c
  group user
    ../USER/: safe_main.c arm_safety.c safe_console.c servo_bus.c
software components: CMSIS:CORE 6.2.0
